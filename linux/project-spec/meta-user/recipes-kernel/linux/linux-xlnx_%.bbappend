SRC_URI += "file://user_2021-12-22-01-44-00.cfg \
            file://user_2021-12-22-03-09-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

